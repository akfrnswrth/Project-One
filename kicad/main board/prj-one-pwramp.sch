File: kicad/main board/prj-one-pwramp.sch (KiCad schematic (older format))
At the start: 70 parts

Commit message: Switch to op-amp based design
Parts:
- gave numbers to parts that had none: 70
